# Keil uVision project cache.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: CT_Board_HS14_M4 STMicroelectronics
  pack: InES.CTBoard14_DFP.4.0.3
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cache
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-padded
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress 6314
  group app
    ./App/: main.c
    ./app/: arrays.c cache.c simulation.c
software components: Device:Startup 4.0.1, HAL:CT Board:7 segment 4.0.0, HAL:CT Board:LCD 3.0.3, HAL:FMC 3.0.1, HAL:GPIO 4.0.1, HAL:PWR 2.2.0, HAL:RCC 4.0.1, HAL:TIMER 4.0.1
